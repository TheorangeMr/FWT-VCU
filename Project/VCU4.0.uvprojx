# Keil uVision project VCU4.0.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: VCU4.3 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Library\STM32F10x_StdPeriph_Driver\inc;..\User;..\Library\CMSIS;..\FreeRtos\include;..\FreeRtos\portable;..\FreeRtos\portable\ARM_CM3;..\BSP\USART;..\BSP\CAN;..\BSP\ADC;..\BSP\DMA;..\BSP\TIMER;..\BSP\SDIO_SD;..\BSP\FatFs\source;..\BSP\UART2;..\BSP\RingBuffer;..\User\MALLOC;..\BSP\ATK-M750;..\BSP\PWR;..\BSP\IWDG;..\User\delay-FreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Library/CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ../User/: main.c stm32f10x_it.c FreeRTOSConfig.h
    ../User/MALLOC/: malloc.c
    ../User/delay-FreeRTOS/: bsp_delay.c
  group CMSIS
    ../Library/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWIBL
    ../Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group DOC
    ../Dos/: readme.txt
  group FreeRTOS/Source
    ../FreeRtos/source/: croutine.c event_groups.c list.c tasks.c queue.c timers.c
  group FreeRTOS/Ports
    ../FreeRtos/portable/ARM_CM3/: port.c
    ../FreeRtos/portable/MemMang/: heap_4.c
  group BSP
    ../BSP/CAN/: bsp_can.c
    ../BSP/DMA/: bsp_dma.c
    ../BSP/TIMER/: bsp_timer.c
    ../BSP/SDIO_SD/: bsp_sdio_sdcard.c
    ../BSP/RingBuffer/: RingBuffer.c
    ../BSP/ATK-M750/: atk_m750.c
    ../BSP/UART2/: uart2.c
    ../BSP/PWR/: bsp_pwr.c
    ../BSP/USART/: usart.c
    ../BSP/ADC/: bsp_adc.c
    ../BSP/IWDG/: bsp_iwdg.c
  group FatFs
    ../BSP/FatFs/source/: diskio.c ff.c ffsystem.c ffunicode.c
